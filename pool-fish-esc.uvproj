# Keil uVision project pool-fish-esc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000) MODP2
  output: pool-fish-esc +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: __CX51__, __CONF_MCU_MODEL=MCU_MODEL_STC8H1K28,__CONF_FOSC=24000000UL
  c include: .\FwLib_STC8\include
  group Source Group 1
    ./: main.c
  group FwLib_STC8
    ./FwLib_STC8/src/: fw_adc.c fw_i2c.c fw_mem.c fw_spi.c fw_sys.c fw_tim.c fw_uart.c fw_usb.c fw_util.c
